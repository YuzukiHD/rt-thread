## bsp/allwinner-hal/sun252iw2/Kconfig
```kconfig
mainmenu "RT-Thread Configuration"

config BOARD_SUN252IW2
    bool
    default y

source "$RTT_ROOT/Kconfig"
```
